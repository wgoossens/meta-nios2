include u-boot-sopcinfo.inc
DEFAULT_PREFERENCE_nios2 = "1"
PV = "2012.04.01"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/${PV}:"

